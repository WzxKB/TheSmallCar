# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app\src;.\bsp\inc;.\bsp\src
  group app
    ./app/src/: main.c
  group bsp
    ./bsp/src/: bsp.c config.c bsp_adc.c delay.c UART.c nrf.c SW.c LED.c
  group inc
    ./bsp/inc/: bsp.h config.h name.h bsp_adc.h delay.h UART.h nrf.h SW.h LED.h
