# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\bsp\inc;.\bsp\src;.\app\src;.\app\src;.\bsp;.\app
  group app
    ./app/src/: main.c
  group bsp
    ./bsp/: bsp.c
    ./bsp/src/: config.c nrf.c UART.c dealy.c LED.c INT.c pwm.c
  group inc
    ./bsp/: bsp.h
    ./bsp/inc/: config.h name.h nrf.h UART.h delay.h LED.h INT.h pwm.h
